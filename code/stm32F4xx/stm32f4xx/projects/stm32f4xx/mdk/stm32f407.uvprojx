# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: master_firmware_YLJ_V1.0.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT = 1,__TARGET_FPU_VFP
  c include: ..\..\..\..\compoents\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\compoents\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\..\..\compoents\CMSIS\Include;..\..\..\..\compoents\STM32F4xx_HAL_Driver\Inc;..\..\..\..\compoents\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\compoents\Utilities;..\..\..\components\bsp\stm32l4xx_bsp\inc;..\..\..\components\bsp\stm32l4xx_bsp;..\..\..\components\bsp;..\..\..\components\mdl\clog;..\..\..\components\mdl\osal\ports;..\..\..\components\mdl\osal\src;..\..\..\components\mdl\rttviewer;..\source;..\source\application\hal_task;..\source\application\user_task;..\source\fml\system;..\..\..\components\bsp\stm32f4xx_bsp\inc;..\..\..\components\bsp\stm32f4xx_bsp\src;..\..\..\components\bsp\stm32f4xx_bsp;..\..\..\..\compoents\STM32F4xx_StdPeriph_Driver\inc;..\..\..\components\mdl\MALLOC;..\source\fml\ad7988_1\port;..\source\fml\ad7988_1\src;..\source\application\vibrate_task;..\source\fml\ad7988_1;..\source\fml\temperatue_4_20mV;..\source\fml\protocol;..\..\..\..\compoents\CMSIS\DSP_Lib\Source\ComplexMathFunctions;..\..\..\..\compoents\CMSIS\DSP_Lib\Source\ControllerFunctions;..\source\fml\transfor;..\source\fml\conf;..\..\..\components\mdl\version
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Hal_task
    ../source/application/hal_task/: hal_task.c
  group User_task
    ../source/application/user_task/: user_task.c
  group Vibrate_task
    ../source/application/vibrate_task/: vibrate_task.c
  group Bsp
    ../../../components/bsp/: bsp_init.c stm32_bsp_conf.h bsp_led.c bsp_fft_integral.c
    ../../../components/bsp/stm32f4xx_bsp/src/: stm32f4xx_bsp_systick.c stm32f4xx_bsp_usart.c stm32f4xx_bsp_adc.c stm32f4xx_bsp_spi.c stm32f4xx_bsp_iic.c stm32f4xx_bsp_exti.c stm32f4xx_bsp_tim.c stm32f4xx_bsp_flash.c
    ../../../components/bsp/stm32f4xx_bsp/: stm32f4xx_bsp_conf.h
  group Fml
    ../source/fml/system/: system_init.c system_param.c
    ../source/fml/ad7988_1/port/: ad7988_port.c
    ../source/fml/temperatue_4_20mV/: t_4_20mv.c
    ../source/fml/ad7988_1/src/: ad7988_core.c
    ../source/fml/protocol/: lnprotocol.c
    ../source/fml/transfor/: transfor_makepackage.c
    ../source/fml/conf/: app_conf.c
  group Utilities
    ../../../../compoents/Utilities/: crc.c
  group Mdl
    ../../../components/mdl/clog/: clog.c
    ../../../components/mdl/osal/ports/: osal_cpu.c
    ../../../components/mdl/osal/src/: osal.c osal_cfg.c osal_clock.c osal_core.c osal_msg.c osal_task.c osal_timeout.c osal_timer.c
    ../../../components/mdl/rttviewer/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../components/mdl/MALLOC/: malloc.c
    ../../../components/mdl/version/: version.c
  group Driver
    ../../../../compoents/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../../../compoents/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../../../../compoents/CMSIS/DSP_Lib/ARM/: arm_cortexM4lf_math.lib
  group Source
    ../source/: main.c self_def.h stm32f4xx_it.c system_stm32f4xx.c
